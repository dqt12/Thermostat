# Keil uVision project Project_12345.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32F12345 Holtek
  pack: Holtek.HT32_DFP.1.0.10
  cpu: IROM(0x00000000-0x0000FBFF) IRAM(0x20000000-0x20003FFF) CPUTYPE("Cortex-M3") CLOCK(8000000)
  output: HT32 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F12345_DVB, USE_HT32F12345
  c include: ..\;..\library\HT32F1xxxx_Driver\inc;..\library\CMSIS\Include;..\library\Device\Holtek\HT32F1xxxx\Include;..\library\HT32_USBD_Library\inc;..\utilities;..\drv;..\common
  asm define: USE_HT32_CHIP=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f1xxxx_01_it.c ESP8266.c queue.c ht32_usbd_descriptor.c ht32_usbd_class.c iap_buffer.c iap_crc16.c iap_handler.c iap_xmodem.c lcd_display.c touch_screen.c
  group Config
    ./: HT32F1xxxx_01_DebugSupport.ini ht32_op.s
    ../: ht32f1xxxx_conf.h ht32f1xxxx_01_usbdconf.h
  group CMSIS
    ../: system_ht32f1xxxx_02.c
  group MDK-ARM
    ./: startup_ht32f1xxxx_01.s
  group Drv
    ../drv/: ZH_GPTM.c spi_flash_MX66L51235F.c lcm_ssd1963_480x272_5Inch.c
  group USBD_Library
    ../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../library/HT32F1xxxx_Driver/src/: ht32_cm3_misc.c ht32f1xxxx_adc.c ht32f1xxxx_bftm.c ht32f1xxxx_ckcu.c ht32f1xxxx_cmp.c ht32f1xxxx_crc.c ht32f1xxxx_ebi.c ht32f1xxxx_exti.c ht32f1xxxx_flash.c ht32f1xxxx_gpio.c ht32f1xxxx_i2c.c ht32f1xxxx_i2s.c ht32f1xxxx_mctm.c ht32f1xxxx_pdma.c ht32f1xxxx_pwrcu.c ht32f1xxxx_rstcu.c ht32f1xxxx_rtc.c ht32f1xxxx_sdio.c ht32f1xxxx_spi.c ht32f1xxxx_tm.c ht32f1xxxx_usart.c ht32f1xxxx_usbd.c ht32f1xxxx_wdt.c
  group Retarget
    ../library/HT32F1xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../utilities/: ht32_board.c
